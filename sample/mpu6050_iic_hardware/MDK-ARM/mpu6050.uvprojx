# Keil uVision project mpu6050.uvprojx, settings and files
target mpu6050 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: mpu6050 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103x6,MPL_LOG_NDEBUG=1,MPU6050,EMPL,USE_DMP,EMPL_TARGET_STM32F4
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;..\mpu6050
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103x6.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c i2c.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_i2c.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group mpu6050
    ../mpu6050/: data_builder.c eMPL_outputs.c hal_outputs.c inv_mpu.c inv_mpu_dmp_motion_driver.c log_stm32.c message_layer.c ml_math_func.c mlmath.c mpl.c mpu6050.c results_holder.c start_manager.c storage_manager.c libmpllib.lib data_builder.h dmpKey.h dmpmap.h eMPL_outputs.h fast_no_motion.h fusion_9axis.h gyro_tc.h hal_outputs.h heading_from_gyro.h inv_math.h inv_mpu.h inv_mpu_dmp_motion_driver.h invensense.h invensense_adv.h log.h mag_disturb.h message_layer.h ml_math_func.h mlinclude.h mlmath.h mlos.h mltypes.h motion_no_motion.h mpl.h mpu.h mpu6050.h no_gyro_fusion.h packet.h quaternion_supervisor.h readme.txt results_holder.h start_manager.h stdint_invensense.h storage_manager.h
software components: CMSIS:CORE 5.0.1
